# Keil uVision project gps_firmware.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 数传Type +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\main;..\CORE;..\STM32F10x_FWLib\inc;..\System\sys;..\System\usart;..\System\delay;..\System\type\inc;..\program;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\Tasks;..\fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group 主函数
    ../main/: main.c stm32f10x_it.c Struct.c Struct.h
  group SYSTEM
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/type/src/: ring_buffer.c
    ../program/: LED.c timer.c usart.c usart2.c iic.c tft.c spi.c hmc5883.c gps.c Kalman.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
    ../main/: system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Fonts
    ../fonts/: font-asc.c font16-cn.c
